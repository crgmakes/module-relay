File: pcb/interface.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Changed opto to be a little smaller
Updated to v10
Parts:
- J2, J6, TP15, TP16: value ~ -> (none)
