File: pcb/power.kicad_sch (KiCad schematic)
At the start: 13 parts

Commit message: Changed opto to be a little smaller
Updated to v10
Parts:
- J3, J4, JP1, JP4, TP20, TP21, TP22: value ~ -> (none)
